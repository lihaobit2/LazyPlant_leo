# Keil uVision project Project.uvprojx, settings and files
target IOT STUNO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin .\Obj\Project.axf  --output ..\Output\Project.bin
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, STUNO
  c include: ..\Lib\CM3;..\Lib\inc;..\User;..\User\Hal_EXTI;..\User\Hal_Usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c delay.c RTC.c
    ../User/GPIO/: sa_gpio.c
  group Hal
    ../User/Hal_rgb_led/: hal_rgb_led.c
    ../User/Hal_Usart/: hal_uart.c
    ../User/Hal_key/: hal_key.c
    ../User/Hal_led/: Hal_led.c
    ../User/hal_motor/: hal_motor.c
    ../User/hal_temp_hum/: hal_temp_hum.c
    ../User/hal_infrared/: hal_infrared.c
    ../User/Hal_OLED/: Hal_OLED.c AsciiLib.c
    ../User/hal_moisture/: hal_moisture.c
    ../User/hal_pump/: hal_pump.c
    ../User/hal_fan/: Hal_fan.c
    ../User/hal_light_inten/: Hal_light_inten.c
    ../User/hal_extr_pump/: hal_extr_pump.c
  group Protocol
    ../User/Protocol/: Protocol.c
  group CMSIS
    ../Lib/CM3/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
target Xnucleo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: as above
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, Xnucleo
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GoKit (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Gokit +hex
  AfterMake: as above
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, Gokit
  c include: ..\Lib\CM3;..\Lib\inc;..\User;..\User\Hal_EXTI;..\User\Hal_Usart;..\User\Hal_moisture;..\User\hal_pump;..\User\hal_light_inten;..\User\hal_extr_pump;..\User\hal_fan
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
